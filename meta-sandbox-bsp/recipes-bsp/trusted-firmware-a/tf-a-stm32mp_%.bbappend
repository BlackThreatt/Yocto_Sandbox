FILESEXTRAPATHS:prepend := "${THISDIR}:"